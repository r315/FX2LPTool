# Keil uVision project Vend_Ax.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB 8051 AnchorChips
  cpu: IRAM(0 - 0xFF) CLOCK(25000000) MODDP2
  output: Vend_Ax +hex
  AfterMake: ..\..\Bin\hex2bix -i -f 0xC2 -o Vend_Ax.iic Vend_Ax.hex
  c flags: Optimize=6 SizeSpeed=1
  c define: NO_RENUM
  group Source Group 1
    ./: FW.C VEND_AX.C DSCR.A51
    ./: USBJmpTb.OBJ EZUSB.LIB
